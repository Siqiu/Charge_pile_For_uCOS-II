<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>FLASH</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\datstr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-Config\includes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Module_BSP.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Module_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Module_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Module_DLT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Module_LED.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Module_Protocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Module_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Module_uart.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <group>
      <name>Drivers</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Drivers\source\debug_frmwrk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Drivers\source\lpc17xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Drivers\source\lpc17xx_clkpwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Drivers\source\lpc17xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Drivers\source\lpc17xx_libcfg_default.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Drivers\source\lpc17xx_nvic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Drivers\source\lpc17xx_pinsel.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Drivers\source\lpc17xx_timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Drivers\source\lpc17xx_uart.c</name>
      </file>
    </group>
    <group>
      <name>OS</name>
      <file>
        <name>$PROJ_DIR$\..\..\BSP\OS\uCOS-II\bsp_os.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\BSP\OS\uCOS-II\bsp_os.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\bsp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Core\Device\Include\LPC17xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Donatello\lpc17xx_libcfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\BSP\IAR\startup_LPC17xx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Software\Donatello\Core\Device\Source\Templates\system_LPC17xx.c</name>
    </file>
  </group>
  <group>
    <name>uCOS-II</name>
    <group>
      <name>uC/CPU</name>
      <group>
        <name>ARM-Cortex-M3</name>
        <group>
          <name>IAR</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M3\IAR\cpu.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M3\IAR\cpu_a.asm</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M3\IAR\cpu_c.c</name>
          </file>
        </group>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CPU\cpu_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CPU\cpu_core.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CPU\cpu_def.h</name>
      </file>
    </group>
    <group>
      <name>uC/CSP</name>
      <group>
        <name>MCU</name>
        <group>
          <name>NXP</name>
          <group>
            <name>LPC17xx</name>
            <group>
              <name>LPC1768</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CSP\MCU\NXP\LPC17xx\LPC1768\csp_dev.h</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CSP\MCU\NXP\LPC17xx\csp_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CSP\MCU\NXP\LPC17xx\csp_grp.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CSP\MCU\NXP\LPC17xx\csp_int.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CSP\MCU\NXP\LPC17xx\csp_pm.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CSP\MCU\NXP\LPC17xx\csp_tmr.c</name>
            </file>
          </group>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CSP\MCU\csp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CSP\MCU\csp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-CSP\MCU\csp_types.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>uC/LIB</name>
      <group>
        <name>Ports</name>
        <group>
          <name>ARM-Cortex-M3</name>
          <group>
            <name>IAR</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-LIB\Ports\ARM-Cortex-M3\IAR\lib_mem_a.asm</name>
            </file>
          </group>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-LIB\lib_ascii.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-LIB\lib_math.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-LIB\lib_mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uC-LIB\lib_str.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>uC/OS-III</name>
      <group>
        <name>Port</name>
        <group>
          <name>ARM-Cortex-M3</name>
          <group>
            <name>CSP</name>
            <group>
              <name>Generic</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Ports\ARM-Cortex-M3\CSP\Generic\os_csp.c</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Ports\ARM-Cortex-M3\CSP\os_csp.h</name>
            </file>
          </group>
          <group>
            <name>Generic</name>
            <group>
              <name>IAR</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu.h</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu_a.asm</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu_c.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\os_dbg.c</name>
              </file>
            </group>
          </group>
        </group>
      </group>
      <group>
        <name>Source</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Source\os_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Source\os_flag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Source\os_mbox.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Source\os_mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Source\os_mutex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Source\os_q.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Source\os_sem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Source\os_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Source\os_time.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-II\Source\os_tmr.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>uCOSII_Config</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-Config\app_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-Config\app_hooks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-Config\cpu_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-Config\csp_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-Config\os_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Software\uCOS-Config\os_cfg_app.h</name>
      </file>
    </group>
  </group>
</project>


