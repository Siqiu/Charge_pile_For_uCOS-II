# Keil uVision project uCOS-II.uvproj, settings and files
target uCOS-II (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: uCOS-II
  c flags: Optim=1
  c include: ..\..\uCOS-II;..\..\uCOS-II\KeilMDK;..\..\BSP;..\..\BSP\OS\uCOS-II;..\..\BSP\KeilMDK;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-LIB;..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\..\..\..\uCOS-II\Source;..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M3\CSP;..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M3\CSP\Generic;..\..\..\..\..\uC-CSP\MCU;..\..\..\..\..\uC-CSP\MCU\NXP\LPC17xx;..\..\..\..\..\uC-CSP\MCU\NXP\LPC17xx\LPC1768
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group APP
    ../: app.c app_hooks.c cpu_cfg.h csp_cfg.h includes.h os_cfg.h os_cfg_app.h
    ./: app_cfg.h
  group BSP
    ../../BSP/: bsp.c bsp.h
    ../../BSP/OS/uCOS-II/: bsp_os.c bsp_os.h
    ../../BSP/KeilMDK/: cstartup.s
  group uC-CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../../../../uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC-CSP
    ../../../../../uC-CSP/MCU/: csp.c csp.h csp_types.h
    ../../../../../uC-CSP/MCU/NXP/LPC17xx/: csp_gpio.c csp_grp.h csp_int.c csp_pm.c csp_tmr.c
    ../../../../../uC-CSP/MCU/NXP/LPC17xx/LPC1768/: csp_dev.h
  group uC-LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uCOS-II Ports
    ../../../../../uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
    ../../../../../uCOS-II/Ports/ARM-Cortex-M3/CSP/Generic/: os_csp.c
    ../../../../../uCOS-II/Ports/ARM-Cortex-M3/CSP/: os_csp.h
  group uCOS-II Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
