# IAR project uCOS-II.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pe174,Pa050,Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\Software\uCOS-II; ..\..\BSP; ..\..\BSP\OS\uCOS-II; ..\..\..\..\..\Software\uCOS-Config; ..\..\..\..\..\Software\uC-CSP\MCU; ..\..\..\..\..\Software\uC-CSP\MCU\NXP\LPC17xx; ..\..\..\..\..\Software\uC-CSP\MCU\NXP\LPC17xx\LPC1768; ..\..\..\..\..\Software\uCOS-II\Ports\ARM-Cortex-M3\CSP; ..\..\..\..\..\Software\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\Software\uCOS-II\Source; ..\..\..\..\..\Software\uC-LIB; ..\..\..\..\..\Software\uC-CPU; ..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\Software\Donatello; ..\..\..\..\..\Software\Donatello\Core\CMSIS\Include; ..\..\..\..\..\Software\Donatello\Core\Device\Include; ..\..\..\..\..\Software\Donatello\Drivers\source; ..\..\..\..\..\Software\Donatello\Drivers\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uCOS-III-TCPIP-V2.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\ldscript_irom_iar.ld
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../../../../../Software/Donatello/: datstr.h Module_BSP.c Module_can.c Module_crc.c Module_DLT.c Module_LED.c Module_Protocol.c Module_RFID.c Module_timer.c Module_uart.c
    ../../../../../Software/uCOS-Config/: includes.h
    ../: main.c
  group BSP
    ../../BSP/: bsp.c bsp.h
    ../../../../../Software/Donatello/Core/Device/Include/: LPC17xx.h
    ../../../../../Donatello/: lpc17xx_libcfg.h
    ../../BSP/IAR/: startup_LPC17xx.s
    ../../../../../Software/Donatello/Core/Device/Source/Templates/: system_LPC17xx.c
  group BSP/Drivers
    ../../../../../Software/Donatello/Drivers/source/: debug_frmwrk.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_timer.c lpc17xx_uart.c
  group BSP/OS
    ../../BSP/OS/uCOS-II/: bsp_os.c bsp_os.h
  group uCOS-II/uC/CPU
    ../../../../../Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uCOS-II/uC/CPU/ARM-Cortex-M3/IAR
    ../../../../../Software/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uCOS-II/uC/CSP/MCU
    ../../../../../Software/uC-CSP/MCU/: csp.c csp.h csp_types.h
  group uCOS-II/uC/CSP/MCU/NXP/LPC17xx
    ../../../../../Software/uC-CSP/MCU/NXP/LPC17xx/: csp_gpio.c csp_grp.h csp_int.c csp_pm.c csp_tmr.c
  group uCOS-II/uC/CSP/MCU/NXP/LPC17xx/LPC1768
    ../../../../../Software/uC-CSP/MCU/NXP/LPC17xx/LPC1768/: csp_dev.h
  group uCOS-II/uC/LIB/Ports
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOS-II/uC/LIB/Ports/ARM-Cortex-M3/IAR
    ../../../../../Software/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uCOS-II/uC/OS-III/Port/ARM-Cortex-M3/CSP
    ../../../../../Software/uCOS-II/Ports/ARM-Cortex-M3/CSP/: os_csp.h
  group uCOS-II/uC/OS-III/Port/ARM-Cortex-M3/CSP/Generic
    ../../../../../Software/uCOS-II/Ports/ARM-Cortex-M3/CSP/Generic/: os_csp.c
  group uCOS-II/uC/OS-III/Port/ARM-Cortex-M3/Generic/IAR
    ../../../../../Software/uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/uC/OS-III/Source
    ../../../../../Software/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/uCOSII_Config
    ../../../../../Software/uCOS-Config/: app_cfg.h app_hooks.c cpu_cfg.h csp_cfg.h os_cfg.h os_cfg_app.h
